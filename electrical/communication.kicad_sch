File: electrical/communication.kicad_sch (KiCad schematic)
At the start: 21 parts

Commit message: Upgraded G3X Touch to Axis
Parts:
- ACX-BT, COPILOT_LEMO, GTR20, PILOT_LEMO: value ~ -> (none)
