File: electrical/autopilot.kicad_sch (KiCad schematic)
At the start: 9 parts

Commit message: Upgraded G3X Touch to Axis
Parts:
- GMC507, GSA28_PITCH, GSA28_ROLL, GSA28_YAW: value ~ -> (none)
